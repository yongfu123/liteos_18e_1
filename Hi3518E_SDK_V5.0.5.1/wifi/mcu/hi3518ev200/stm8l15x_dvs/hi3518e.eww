<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\hi3518e.ewp</path>
  </project>
  <batchBuild/>
</workspace>


