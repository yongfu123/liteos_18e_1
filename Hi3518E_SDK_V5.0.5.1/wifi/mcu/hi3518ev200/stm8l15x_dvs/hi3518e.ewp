# IAR project hi3518e.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151F3 STM8L151F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: STM8L15x_StdPeriph_Driver\inc; $PROJ_DIR$
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: hi3518e.hex
  ILINK.IlinkOutputFile: hi3518e.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group STM8L15x_StdPeriph_Driver
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_itc.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_tim3.c stm8l15x_usart.c
    STM8L15x_StdPeriph_Driver/inc/: stm8l15x_adc.h stm8l15x_clk.h
  group user
    ./: adc.c adc.h boardconfig.h halt.c halt.h kfifo.c kfifo.h main.c rtc.c rtc.h stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
